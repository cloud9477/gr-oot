options:
  parameters:
    generate_options: qt_gui
    id: oot1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: oot_multiply_0
  id: oot_multiply
  parameters: {}
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', oot_multiply_0, '0']
- [analog_sig_source_x_0, '0', qtgui_sink_x_0, '0']
- [oot_multiply_0, '0', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
